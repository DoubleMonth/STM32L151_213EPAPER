# Keil uVision project STM32L151C8TxA.uvprojx, settings and files
target STM32L151C8TxA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L151C8xxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L151C8TxA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA
  c include: ../Core/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;..\BSP;..\Fonts;..\rt-thread-3.1.3\include\libc;..\rt-thread-3.1.3\include;..\rt-thread-3.1.3\libcpu\arm\cortex-m3;..\rt-thread-3.1.3\libcpu;..\rt-thread-3.1.3\src;..\rt-thread-3.1.3;..\packages\pcf8563
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l151xba.s
  group BSP
    ../BSP/: epd2in13.c epdif.c epdpaint.c imagedata.c
  group Fonts
    ../Fonts/: font8.c font12.c font16.c font20.c font24.c font80.c font21.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_spi.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group RTThread
    ../rt-thread-3.1.3/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../rt-thread-3.1.3/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../rt-thread-3.1.3/: board.c
software components: CMSIS:CORE 4.3.0
